# Keil uVision project es_sdk.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: es_sdk +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\ESC51_sdk\es_sdkstatrt;..\..\ESC51_sdk\HW_Driver\header;..\..\ESC51_sdk\HW_Support\header;..\..\ESC51_sdk\SW_Support\header;..\..\ESC51_project;..\..\ESC51_sdk
  group es_user
    ../: user.c
    ../../ESC51_sdk/es_sdkstatrt/: user_config_prj.h
  group es_hw_driver
    ../../ESC51_sdk/HW_Driver/: ad0809.c ad5320.c ad9850.c at24c02.c button4x4.c dht11.c DigitalTube6.c drv_button.c drv_CC1101.c drv_spi.c ds18b20.c ds1302.c esp8266.c hcsr04.c hx711.c iic.c LCD1602.c lcd12864.c max263.c MAX541x.c max1241.c pwm.c
  group es_sw_support
    ../../ESC51_sdk/SW_Support/: sw_GCapture.c sw_Gdelay.c sw_PWMGroup.c sw_SoftTimer.c
  group es_hw_support
    ../../ESC51_sdk/HW_Support/: hw_Gtimer.c hw_ioctrl.c hw_MEMPool.c hw_Timer0.c hw_Timer1.c hw_Timer2.c hw_UART.c
    ../../ESC51_sdk/HW_Support/header/: hw_critical.h hw_vartype.h
  group es_main
    ../../ESC51_sdk/es_sdkstatrt/: bsp_config.c es_main.c es_sys_package.h
  group es_start
    ./: STARTUP.A51
